# Keil uVision project camera.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\EXTI;..\HARDWARE\LCD;..\HARDWARE\SCCB;..\HARDWARE\OV7620;..\HARDWARE\TIMER;..\HARDWARE\DMA;..\HARDWARE\OV7670;..\SYSTEM\delay;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\SAVE_RGB;..\HARDWARE\SD;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\FATFS\src\option;..\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/SCCB/: sccb.c
    ../HARDWARE/OV7670/: ov7670.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SAVE_RGB/: save_rgb.c
    ../HARDWARE/SD/: MMC_SD.C
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
